# Keil uVision project GlideLockV3.uvprojx, settings and files
target GlideLockV3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GlideLockV3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\stm32f10x\inc;..\USER;..\HARDWARE;..\MODULE;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../stm32f10x/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group HARDWARE
    ../HARDWARE/: key.c key.h led.c led.h parameter.c parameter.h pid.c pid.h pwm.c pwm.h pwmin.c glideLock.c glideLock.h timer.c timer.h parameterList.c flags.h flash.c flash.h adc.c adc.h
  group MODULE
    ../MODULE/: mixer.c mixer.h stroke.c mathHelper.h mathHelper.c logger.c logger.h
    ./: stroke.h
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
